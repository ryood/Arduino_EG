# Repository ryood/Arduino_EG

## EAGLE design eagle/Arduino_EG/Arduino_EG.brd

Parts:
C1, C2, C4: 47uF; E2,5-7
C3: 0.1uF; C025-025X050
CN1: +9VPWR; B2B-XH-A
D1, D2: 1N4148; DO35-7
IC1: LM358; DIL08
JP1: RSus; 1X03
JP2: Rdcy; 1X02
JP3: Ratk; 1X02
JP4: Rrls; 1X02
JP5: Out; 1X02
JP6: INDICATOR; 1X02
JP7: Rlvl; 1X03
JP8: GateIn; 1X02
JP9: TP-GND; 1X02
Q1: 2N7000; TO92-
R1: 6.8k; 0207/7
R2: 1M; 0207/7
R3: 1k; 0207/7
R4: 10k; 0207/7
R5: 100; 0207/7
T1: 2SA1015; TO92-ECB
U$1: PRO-MINI

Connections:
+5V: C2.+, JP7.1, R1.2, U$1.VCC
A0: C1.+, IC1.5 (+IN), JP2.2, JP3.2, JP4.2, U$1.A0
D5: D1.A, U$1.D5
D6: Q1.2 (G), R2.2, U$1.D6
D7: D2.C, U$1.D7
GND: C1.-, C2.-, C3.2, C4.-, CN1.2, IC1.4 (V-), JP5.2, JP6.2, JP7.3, JP8.2, JP9.1, JP9.2, Q1.3 (S), R2.1, R4.1, T1.C, U$1.GND
unnamed: JP1.1, R1.1
unnamed: JP1.3, Q1.1 (D)
unnamed: JP1.2, T1.B
unnamed: JP2.1, T1.E
unnamed: JP5.1, R5.2
unnamed: D1.C, JP3.1
unnamed: D2.A, JP4.1
unnamed: IC1.1 (OUT), IC1.2 (-IN), R3.1
unnamed: JP7.2, U$1.A1
unnamed: JP6.1, R3.2
unnamed: JP8.1, R4.2, U$1.D3
OUT: IC1.3 (+IN), IC1.6 (-IN), IC1.7 (OUT), R5.1
V+: C3.1, C4.+, CN1.1, IC1.8 (V+), U$1.RAW

Notes on the sheet:
R1はピンソケットで実装
C1はピンソケットで実装
Arduino Pro Mini 16MHz/5V

Board: 2 copper layers, 94.0 x 71.1 mm, 25 parts (0 on the bottom side), 19 nets.

## Commit log

2018-07-09 Arduino EG 構想
2018-07-09 Update: flitzing files, arduino sketch
2018-07-23 Add eagle files
2018-07-25 Update eagle files
2018-07-25 Update Arduino sketch
2018-07-28 Update Arduino sketch, Eagle files
2018-07-28 Update Arduino_EG ピンアサインを変更
2018-08-11 Add case design
